PV = "20180904"

require edision-blindscan-utils.inc

COMPATIBLE_MACHINE = "osmio4k"

SRC_URI[md5sum] = "f9f98ca43db00590491320168dc7b45f"
SRC_URI[sha256sum] = "f91f1e183f83d0db1bd48665d93d5725751058e2f5502db4990cefd7c7dae4fa"
