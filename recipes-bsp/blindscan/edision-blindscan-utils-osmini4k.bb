PV = "20200323"

require edision-blindscan-utils.inc

COMPATIBLE_MACHINE = "osmini4k"

SRC_URI[md5sum] = "e9a5b55d27d30ad2d10ed6fbef356e8f"
SRC_URI[sha256sum] = "2af5546548b9bad5c13dccd2325f24fa111e507c0dd720e5000ec07ec66661cf"
