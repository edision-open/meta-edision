KV = "4.3.0"
SRCDATE = "20160314"

COMPATIBLE_MACHINE = "osmini"

require os-dvb-modules.inc

SRC_URI[md5sum] = "a5a7fabba3398212d077021eb232f3f8"
SRC_URI[sha256sum] = "fcd7d2697fcba52a0284056fb81203ab3dd83a22cd3689ab8aeacc1e7177c327"
