KV = "4.8.17"
SRCDATE = "20180719"
MODNAMES = "linuxdvb"

require os-dvb-modules.inc

COMPATIBLE_MACHINE = "osninoplus"

SRC_URI[md5sum] = "2235d5a9df77c2d550eb5ee5200e66b1"
SRC_URI[sha256sum] = "ff6d9df2380ad455d4aa238bea788819a9fe2c0369ed8f38d04bb7db5f548de9"
