KV = "4.8.17"
SRCDATE = "20180509"
MODNAMES = "linuxdvb"

require os-dvb-modules.inc

COMPATIBLE_MACHINE = "osninopro"

SRC_URI[md5sum] = "fa2b16901882d37332d7ebd81b614a9a"
SRC_URI[sha256sum] = "f14c11099683dc2315fb17bb5cec340e1d6eded1eda7ef95d3e785aff4d6651f"
