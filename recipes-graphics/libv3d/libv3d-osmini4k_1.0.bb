require libv3d.inc
GLES3DIR = "GLES3"

PR = "r0"

COMPATIBLE_MACHINE = "osmini4k"

SRC_URI[md5sum] = "f6a1d15c41968978f1b0fc0af02cba82"
SRC_URI[sha256sum] = "f4863a89059052e085e6daf63039b1ac016d790846d9288fbd2eda002d2697dc"
