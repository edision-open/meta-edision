require libv3d.inc

PR = "r0"

COMPATIBLE_MACHINE = "osmio4k"

SRC_URI[md5sum] = "ce69d44abff7f0052d1ae779c4112931"
SRC_URI[sha256sum] = "c5f670e2620f331764fa24dfed5db59603cc5e236c17dd89155f581949be04ab"
