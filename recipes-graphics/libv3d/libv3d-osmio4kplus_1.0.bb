require libv3d.inc
GLES3DIR = "GLES3"

PR = "r0"

COMPATIBLE_MACHINE = "osmio4kplus"

SRC_URI[md5sum] = "199511c40e24abb9affa776d0eea39ac"
SRC_URI[sha256sum] = "99a84a2ea6599aaead3cc77141495907380614f2c998c8bbb66871f21fff9d3f"
